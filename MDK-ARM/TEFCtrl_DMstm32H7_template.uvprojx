# Keil uVision project TEFCtrl_DMstm32H7_template.uvprojx, settings and files
target TEFCtrl_DMstm32H7_template (6210000::V6.21::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2401FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: TEFCtrl_DMstm32H7_template +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../application;../application/bsp;../application/modules;../application/task;../application/bsp/usart
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c fdcan.c memorymap.c octospi.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
    ../application/: app_main.cpp
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_ospi.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group user/bsp
    ../application/bsp/: bsp_system.h typedef.h
    ../application/bsp/BMI088/: BMI088Middleware.c BMI088Middleware.h BMI088driver.c BMI088driver.h BMI088reg.h bsp_dwt.c bsp_dwt.h
    ../application/bsp/can/: bsp_fdcan.c bsp_fdcan.h
    ../application/bsp/delay/: delay.c delay.h
    ../application/bsp/usart/: bsp_usart.cpp bsp_usart.h
  group user/modules
    ../application/modules/: general_def.h
    ../application/modules/algorithm/Mahony/: MahonyAHRS.c MahonyAHRS.h
    ../application/modules/algorithm/math/: math.c math.h
    ../application/modules/algorithm/PID/: pid_plus.c pid_plus.h pid_test_app.c pid_test_app.h
    ../application/modules/algorithm/_imu/: QuaternionEKF.c QuaternionEKF.h algorithm.c algorithm.h controller.c controller.h kalman_filter.c kalman_filter.h pid.c pid.h user_lib.c user_lib.h
    ../application/modules/motor/dji_motor/: dji_motor.cpp dji_motor.h motor_def.h snail_c615.cpp snail_c615.h
    ../application/modules/motor/dm_motor/: dm_motor.cpp dm_motor.h dm_motor_ctrl.c dm_motor_ctrl.h dm_motor_drv.c dm_motor_drv.h
    ../application/modules/remote/: remoter_uart.c remoter_uart.h
    ../application/modules/ringbuffer/: ringbuffer.c ringbuffer.h ringbuffer_test.c ringbuffer_test.h
  group user/task
    ../application/task/: imu_temp_ctrl.c imu_temp_ctrl.h motor_task.cpp motor_task.h uart_task.cpp uart_task.h
    ../application/task/simple_os/: scheduler.cpp scheduler.h
software components: CMSIS:CORE 5.6.0
